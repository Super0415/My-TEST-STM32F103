# IAR project GenSet001.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; LCD; Font
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GenSet001.srec
  ILINK.IlinkOutputFile: GenSet001.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_common_tables.h arm_const_structs.h arm_math.h ASMCortex.s CAN1Cortex.c CAN1Cortex.h CAN2Cortex.c CAN2Cortex.h CCPCortex.c CCPCortex.h CTLCortex.c CTLCortex.h DBCortex.c DBCortex.h FFTCortex.c FFTCortex.h FWCortex.c FWCortex.h LCDCortex.c LCDCortex.h MODBus10.c MODBus10.h OSCortex.c OSCortex.h SAEJ1939.c SAEJ1939.h SCI1Cortex.c SCI1Cortex.h SCI2Cortex.c SCI2Cortex.h SCI3Cortex.c SCI3Cortex.h SDIOCortex.c SDIOCortex.h SFCortex.c SFCortex.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h TYPCortex.h XIOCortex.c XIOCortex.h
  group Font
    Font/: asc_font.h ascii.h
  group LCD
    LCD/: lcd.c lcd.h lcd_botton.c lcd_botton.h
