# Keil uVision project Template.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 工程模板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\beep;.\APP\SysTick;.\APP\key;.\APP\usart;.\APP\exit;.\APP\smg;.\APP\time;.\APP\PWM;.\APP\RS485;.\APP\printf;.\APP\IIC(24C02);.\APP\AT24Cxx;.\APP\DS18B20;.\APP\ADC;.\APP\hwjs;.\APP\RTC;.\APP\gui;.\APP\lcd;.\APP\DAC;.\APP\PWM_DAC;.\APP\DMA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_dac.c stm32f10x_dma.c
  group APP
    ./APP/LED/: led.c
    ./APP/SysTick/: systick.c
    ./APP/PWM/: pwm.c
    ./APP/RS485/: rs485.c
    ./APP/printf/: printf.c
    ./APP/IIC(24C02)/: iic.c
    ./APP/AT24Cxx/: AT24CXX.c
    ./APP/DS18B20/: ds18b20.c
    ./APP/ADC/: adc.c
    ./APP/RTC/: rtc.c
    ./APP/lcd/: lcd_driver.c
    ./APP/gui/: gui.c
    ./APP/DAC/: dac.c
    ./APP/PWM_DAC/: pwm_dac.c
    ./APP/DMA/: dma.c
    ./APP/beep/: beep.c
    ./APP/exit/: exti.c
    ./APP/hwjs/: hwjs.c
    ./APP/key/: key.c
    ./APP/smg/: smg.c
    ./APP/time/: time.c
    ./APP/usart/: usart.c
