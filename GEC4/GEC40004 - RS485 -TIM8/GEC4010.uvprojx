# Keil uVision project GEC4010.uvprojx, settings and files
target GEC4010 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GEC4010
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\FWLIB\inc;.\USER;.\OS;.\Mylib\XIO;.\Mylib\DB;.\Mylib\SF;.\RS485;.\Modbus\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: stm32f10x_it.c FWCortex.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./CMSIS/: startup_stm32f10x_hd.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group OS
    ./OS/: ASMCortex.s OSCortex.c
  group DB
    ./Mylib/DB/: DB.c
  group XIO
    ./Mylib/XIO/: XIOCortex.c
  group SF
    ./Mylib/SF/: SFCortex.c
  group RS485
    ./RS485/: RS485LIN.c
  group MODBUS
    ./Modbus/ascii/: mbascii.c
    ./Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./Modbus/port/: port.c portevent.c portserial.c porttimer.c
    ./Modbus/rtu/: mbcrc.c mbrtu.c
    ./Modbus/tcp/: mbtcp.c
    ./Modbus/: mb.c
